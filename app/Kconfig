## app/Kconfig
```kconfig
# BLEプロファイルに応じてOS別レイヤーを重ねる機能のON/OFF。
config ZMK_BEHAVIOR_OS_LAYER
    bool "OS Layer switching"
    default n
```
